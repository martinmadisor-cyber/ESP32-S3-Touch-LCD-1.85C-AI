// AIAssistant.cpp - ESP32-S3 client that sends microphone audio to Python WebSocket server
// and receives response audio back for playback
#include <WiFi.h>
#include <ArduinoJson.h>
#include "AIAssistant.h"
#include "config.h"
#include "GUI/GUI.h"

using namespace websockets;
WebsocketsClient client;
String senderSessionId = "";

// Fall back to the compiled-in address when the build environment did not
// supply one, which is the usual case here.
static const char* websocketURL =
    (ENV_WEBSOCKET_URL[0] != '') ? ENV_WEBSOCKET_URL : ASSISTANT_WS_URL_FALLBACK;

// Mode and language settings
static String currentLang = "en";
static String currentMode = "chat";

// Streaming Microphone data state
static bool streamingWave = false;

/*
 Web Socket
*/

// Filled in by the WebSocket task, consumed by loop().
static char pendingAudioURL[256] = {0};
static volatile bool hasPendingAudio = false;

// Called from loop(), where there is stack to spare.
void AIAssistant_PlayPending() {
  if (!hasPendingAudio) return;
  hasPendingAudio = false;
  if (!audio_ptr) return;
  Serial.printf("[AI Assistant] Speaking: %s\n", pendingAudioURL);
  audio_ptr->connecttohost(pendingAudioURL);
}

void onMessageCallback(WebsocketsMessage message)
{
    Serial.print("Received Websocket message");
    if (message.isText())
    {
        const String msg = message.data();

        Serial.printf("[AI Assistant] MSG: %s\n", msg.c_str());

        // Check for simple HELLO or JSON
        if (msg.startsWith("{")) {
          // Parse JSON response
          StaticJsonDocument<512> doc;
          DeserializationError error = deserializeJson(doc, msg);
          if (error) {
            Serial.printf("[AI Assistant] Failed to parse JSON: %s\n", error.c_str());
            return;
          }

          //  // sessions == id(ws)
          const char* type     = doc["type"]     | "unknown";
          const char* content  = doc["content"]  | "";
          const char* language = doc["language"] | "";
          const char* mode     = doc["mode"]     | "";
          const char* sender   = doc["sender"]   | "unspecified";
         
          Serial.println("[AI Assistant] Received assistant message");

          if (strcmp(type, "ASSISTANT_AUDIO_URL") == 0) {
              // The backend renders the reply with a proper voice and serves
              // it over HTTP. Only remember it here: this runs on the
              // WebSocket task, whose 4 KB stack cannot host an HTTP
              // connection and an MP3 decoder, and doing it inline overflowed
              // the stack and rebooted the board.
              Serial.printf("[AI Assistant] Reply audio: %s\n", content);
              strncpy(pendingAudioURL, content, sizeof(pendingAudioURL) - 1);
              pendingAudioURL[sizeof(pendingAudioURL) - 1] = '\0';
              hasPendingAudio = true;
              return;
          } else if (strcmp(type, "ASSISTANT_TEXT_RESPONSE") == 0) {
              Serial.println("[AI Assistant] Agent text response received:");
              Serial.printf("  Sender: %s\n", sender);
              Serial.printf("  Type: %s\n", type);
              Serial.printf("  Content: %s\n", content);
              Serial.printf("  Language: %s\n", language);
              Serial.printf("  Mode: %s\n", mode);

              if (audio_ptr) {
                  audio_ptr->connecttospeech(content, language);
              } else {
                  Serial.println("[AI Assistant] Audio pointer is null!");
              }
              return;
          } else if (strcmp(type, "HELLO") == 0) {
              Serial.printf("  Sender: %s\n", sender);
              Serial.printf("  Type: %s\n", type);
              Serial.println("[AI Assistant] Server acknowledged with HELLO"); 

              // Set backend connection status
              backend_connected = true;

              // Save sender ID globally
              senderSessionId = String(sender);
              Serial.printf("[AI Assistant] Stored session ID: %s\n", senderSessionId.c_str());
              return;
          }
        } else {
          Serial.printf("[AI Assistant] Unrecognized text: %s\n", msg.c_str());
          return;
        }

        Serial.println("Received non-binary message: " + message.data());
        return;
    }

    // Binary
    uint8_t *payload = (uint8_t *)message.c_str();
    size_t length = message.length();

    if (length == 0)
    {
        Serial.println("Received empty audio data");
        return;
    }

    Serial.printf("Received binary audio data of length: %zu bytes\n", length);
    delay(10);
}


void onEventsCallback(WebsocketsEvent event, String data)
{
    if (event == WebsocketsEvent::ConnectionOpened)
    {
        Serial.println("Connection Opened");
    }
    else if (event == WebsocketsEvent::ConnectionClosed)
    {
        Serial.println("Connection Closed");
    }
    else if (event == WebsocketsEvent::GotPing)
    {
        // Serial.println("Got a Ping!");
    }
    else if (event == WebsocketsEvent::GotPong)
    {
        Serial.println("Got a Pong!");
    }
}

// Task to handle WebSocket connection and reconnection logic
// This runs in a separate task to avoid blocking the main loop
void websocketConnectTask(void* parameter) {
  int backoff = 2000;
  const int pollIntervalMs = 10;     // call poll() every 10ms
  const int reconnectCheckMs = 5000; // check connection every 5s

  unsigned long lastReconnectCheck = millis();

  Serial.println("[WebSocket] Starting websocketConnectTask");

  while (true) {
    // Always keep polling to handle incoming data, ping/pong, etc.
    client.poll();
    vTaskDelay(pollIntervalMs / portTICK_PERIOD_MS);

    // Reconnection check (every reconnectCheckMs)
    if (millis() - lastReconnectCheck >= reconnectCheckMs) {
      lastReconnectCheck = millis();

      if (!client.available()) {
        Serial.printf("[WebSocket] Disconnected. Reconnecting... (Backoff: %dms)\n", backoff);

        // The radio is associated only once, at boot, with a 20 s cap. When
        // that failed the board kept retrying the WebSocket forever over an
        // interface with no route, so bring WiFi back before trying again.
        if (WiFi.status() != WL_CONNECTED) {
          Serial.println("[WebSocket] No WiFi - bringing the radio back first");
          WiFi.reconnect();
          vTaskDelay(3000 / portTICK_PERIOD_MS);
          continue;
        }

        if (client.connect(websocketURL)) {
          Serial.println("[WebSocket] Reconnected successfully!");
          client.send(R"({"type":"HELLO"})");
          client.ping();
          backoff = 2000;  // reset backoff
        } else {
          Serial.println("[WebSocket] Reconnect attempt failed.");
          vTaskDelay(backoff / portTICK_PERIOD_MS);
          backoff = min(backoff * 2, 60000);  // exponential backoff up to 60s
        }
      }
    }
  }
  vTaskDelete(NULL);  // not reached, safety
}



void AIAssistant_Init(Audio& audio){
  audio_ptr = &audio;

  Serial.println("[AI Assistant] Connecting to server...");

  client.onMessage(onMessageCallback);
  client.onEvent(onEventsCallback);

  xTaskCreatePinnedToCore(websocketConnectTask, "WebSocketConnectTask", 4096, NULL, 3, NULL, 1);
  Serial.println("[AI Assistant] WebSocket client initialized");
}

void AIAssistant_StartStream() {
  if (client.available()) {
    streamingWave = true;
    client.send(R"({"type":"START_STREAM"})");
    Serial.println("[AI Assistant] Started audio stream: JSON START_STREAM sent");
  } else {
    Serial.println("[AI Assistant] Failed to start stream — WebSocket not available");
  }
}

void AIAssistant_SendAudioChunk(const void* buffer, size_t byteCount) {
  if (client.available()) {
    client.sendBinary(reinterpret_cast<const char*>(buffer), byteCount);
  }
}

void AIAssistant_StopStream() {
  if (client.available() && streamingWave) {
    client.send(R"({"type":"STOP_STREAM"})");
    streamingWave = false;
    Serial.println("[AI Assistant] Stopped audio stream: JSON STOP_STREAM sent");
  } else if (!client.available()) {
    Serial.println("[AI Assistant] Cannot stop stream — WebSocket not available");
  } else if (!streamingWave) {
    Serial.println("[AI Assistant] Stream already stopped or not started");
  }
}

void AIAssistant_Stop() {
  if (client.available()) {
    String json = R"({"type":"STOP_STREAM"})";
    client.send(json);
    Serial.println("[AI Assistant] Sent [STOP] command to server");
  } else {
    Serial.println("[AI Assistant] Cannot send [STOP] — not connected to server");
  }
}
